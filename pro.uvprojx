# Keil uVision project pro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: .\user;.\app\led;.\app\system;.\app\key;.\app\spi;.\app\SD;.\app\usart;.\app\lcd;.\app\gui;.\app\flash;.\app\sram;.\app\malloc;.\app\lpwr;.\app\temp;.\app\dma
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./app/led/: led.c
    ./app/system/: system.c
    ./app/key/: key.c
    ./app/usart/: usart.c
    ./app/gui/: gui.c
    ./app/lcd/: lcd_driver.c
    ./app/SD/: sd.c
    ./app/spi/: spi.c
    ./app/flash/: flash.c
    ./app/adc/: adc.c
    ./app/temp/: temp.c
    ./app/dma/: dma.c
  group user
    ./: STM32F10x.s
    ./user/: main.c
software components: CMSIS:CORE 5.4.0
